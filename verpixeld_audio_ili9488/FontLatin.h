#pragma once

// One UTF-8 code point. Bit 0 of a 5x7 column is the top row.
static uint32_t st_utf8(const uint8_t *&p)
{
    uint8_t c = *p;
    if (!c) return 0;
    p++;
    if (c < 0x80) return c;
    if ((c & 0xE0) == 0xC0 && (*p & 0xC0) == 0x80) {
        uint32_t cp = ((uint32_t)(c & 0x1F) << 6) | (*p & 0x3F);
        p++;
        return cp;
    }
    if ((c & 0xF0) == 0xE0 && (*p & 0xC0) == 0x80 && (p[1] & 0xC0) == 0x80) {
        uint32_t cp = ((uint32_t)(c & 0x0F) << 12) | ((uint32_t)(*p & 0x3F) << 6) | (p[1] & 0x3F);
        p += 2;
        return cp;
    }
    if ((c & 0xF8) == 0xF0 && (*p & 0xC0) == 0x80 && (p[1] & 0xC0) == 0x80 && (p[2] & 0xC0) == 0x80) {
        p += 3;
        return 0xFFFD;
    }
    return 0xFFFD;
}

static const uint8_t *st_font(uint32_t cp)
{
    if (cp >= 'a' && cp <= 'z') cp -= 32;
    switch (cp) {
    case 0x00C4: case 0x00E4: { static const uint8_t g[] = {0x7E,0x11,0x10,0x11,0x7E}; return g; }
    case 0x00D6: case 0x00F6: { static const uint8_t g[] = {0x7E,0x43,0x42,0x43,0x7E}; return g; }
    case 0x00DC: case 0x00FC: { static const uint8_t g[] = {0x3E,0x41,0x40,0x41,0x3E}; return g; }
    case 0x00DF:             { static const uint8_t g[] = {0x36,0x49,0x49,0x36,0x00}; return g; }
    case 0x00C8: case 0x00C9: case 0x00CA: case 0x00CB:
    case 0x00E8: case 0x00E9: case 0x00EA: case 0x00EB:
                             { static const uint8_t g[] = {0x7E,0x4A,0x4A,0x4A,0x01}; return g; }
    case 0x00D1: case 0x00F1: { static const uint8_t g[] = {0x7E,0x09,0x10,0x21,0x7E}; return g; }
    case 0x00C7: case 0x00E7: { static const uint8_t g[] = {0x3C,0x42,0x41,0x22,0x14}; return g; }
    case 0x00D8: case 0x00F8: { static const uint8_t g[] = {0x3E,0x45,0x49,0x51,0x3E}; return g; }
    case 0x00B7: case 0x2022: { static const uint8_t g[] = {0x00,0x00,0x08,0x00,0x00}; return g; }
    case 0x2026:             { static const uint8_t g[] = {0x00,0x40,0x00,0x40,0x40}; return g; }
    case 0x2013: case 0x2014: case 0x2015: cp = '-'; break;
    case 0x2018: case 0x2019: case 0x02BC: cp = '\''; break;
    case 0x201C: case 0x201D: cp = '"'; break;
    case 0x00A0: cp = ' '; break;
    case 0x00C0: case 0x00C1: case 0x00C2: case 0x00C3: case 0x00C5:
    case 0x00E0: case 0x00E1: case 0x00E2: case 0x00E3: case 0x00E5: cp = 'A'; break;
    case 0x00CC: case 0x00CD: case 0x00CE: case 0x00CF:
    case 0x00EC: case 0x00ED: case 0x00EE: case 0x00EF: cp = 'I'; break;
    case 0x00D2: case 0x00D3: case 0x00D4: case 0x00D5:
    case 0x00F2: case 0x00F3: case 0x00F4: case 0x00F5: cp = 'O'; break;
    case 0x00D9: case 0x00DA: case 0x00DB:
    case 0x00F9: case 0x00FA: case 0x00FB: cp = 'U'; break;
    case 0x00C6: case 0x00E6: cp = 'A'; break;
    case 0x00DD: case 0x00FD: case 0x00FF: cp = 'Y'; break;
    default: break;
    }
    if (cp >= 32 && cp <= 'Z') return FONT5x7[cp - 32];
    static const uint8_t miss[] = {0x00,0x00,0x08,0x00,0x00};
    return miss;
}
